* /home/dan/git/KiCAD/ECU_emu/ecu_emu.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Вт 24 окт 2017 16:00:55

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  /+3V3_STM ? ? ? Net-_C2-Pad1_ Net-_C4-Pad1_ ? /ADC_Vbatt /ADC_IGN /ADC_AUX Net-_R7-Pad1_ GND /+3V3_STM Net-_R11-Pad1_ ? ? ? GND /+3V3_STM ? ? ? ? ? ? ? ? ? /stm2lin_UART_TX /stm2lin_UART_RX GND /+3V3_STM ? ? ? ? ? ? ? ? ? ? ? ? ? Net-_J1-Pad3_ GND /+3V3_STM Net-_J1-Pad2_ ? ? ? ? ? ? ? ? ? ? ? ? /stm2lin_SLEEP GND /+3V3_STM STM32F105RBTx
D1  /LIN_Vbatt /ECU_Vbatt PMLL4148L.115
R1  /ADC_Vbatt /ECU_Vbatt 9k
C1  /LIN_Vbatt GND 220uF x 30V
J2  /ECU_solenoid /ECU_HALL_sensor+ ? ? ? GND /ECU_Vbatt /ECU_K-BUS ? /ECU_IGN /ECU_AUX GND Conn_02x06_Top_Bottom
U1  GND Net-_C5-Pad1_ /LIN_Vbatt LD1117S33TR_SOT223
C6  Net-_C5-Pad1_ GND 4.7uF x 10V
C3  /LIN_Vbatt GND 100nF
D2  /+3V3_STM Net-_C5-Pad1_ PMLL4148L.115
J1  /+3V3_STM Net-_J1-Pad2_ Net-_J1-Pad3_ GND Conn_01x04_Male
R4  GND /ADC_Vbatt 2k2
R2  /ADC_IGN /ECU_IGN 9k
R5  GND /ADC_IGN 2k2
R3  /ADC_AUX /ECU_AUX 9k
R6  GND /ADC_AUX 2k2
Y1  Net-_C2-Pad1_ Net-_C4-Pad1_ Crystal
C2  Net-_C2-Pad1_ GND C
C4  Net-_C4-Pad1_ GND C
C5  Net-_C5-Pad1_ GND 10uF
U2  /stm2lin_UART_TX /stm2lin_SLEEP Net-_R9-Pad1_ /stm2lin_UART_RX GND /ECU_K-BUS /LIN_Vbatt Net-_R10-Pad1_ TJA1021T
R8  /stm2lin_UART_RX /+3V3_STM 1k5
D3  /ECU_K-BUS Net-_D3-Pad2_ PMLL4148L.115
R10  Net-_R10-Pad1_ Net-_D3-Pad2_ 1k
C7  /ECU_K-BUS GND 1nF
R9  Net-_R9-Pad1_ /LIN_Vbatt 1k
Q1  Net-_Q1-Pad1_ GND /ECU_solenoid BCV47.215
R11  Net-_R11-Pad1_ Net-_Q1-Pad1_ 10k
R7  Net-_R7-Pad1_ /ECU_HALL_sensor+ 1k

.end
